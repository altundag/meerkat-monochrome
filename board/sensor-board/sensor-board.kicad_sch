File: board/sensor-board/sensor-board.kicad_sch (KiCad schematic)
At the start: 16 parts, among them J1 505110-2091

Commit message: minor changes
Other:
- moved on the sheet: C1, C2, R1
